# Keil uVision project RAK_mine1.0.uvprojx, settings and files
target RAK_mine1.0 (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: RAK_mine1.0
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx
  c misc: --C99
  c include: ../Inc;            ../Drivers/STM32F4xx_HAL_Driver/Inc;            ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;            ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;            ../Drivers/CMSIS/Include;            ..\Hardware\RAK439_DriverLibs_V1.0.6\platform\common\include;            ..\Hardware\RAK439_DriverLibs_V1.0.6\platform\common\mem;            ..\Hardware\RAK439_DriverLibs_V1.0.6\platform\common\rw_os;            ..\Hardware\RAK439_DriverLibs_V1.0.6\examples_nos;            ..\Hardware\RAK439_DriverLibs_V1.0.6\platform\bsp;            ..\Hardware\AD7606;        ../Middlewares/Third_Party/FatFs/src/drivers;        ../Middlewares/Third_Party/FatFs/src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim.c stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rtc.c
  group Application/User
    ../Src/: usart.c gpio.c spi.c main.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c stm32f4xx_it.c adc.c sdio.c tim.c bsp_driver_sd.c fatfs.c rtc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group RAK_SDK/common/include
    ../Hardware/RAK439_DriverLibs_V1.0.6/platform/common/include/: rw_error.h rw_lib.h rw_socket.h
  group RAK_SDK/common/mem
    ../Hardware/RAK439_DriverLibs_V1.0.6/platform/common/mem/: lib_mem.c lib_mem.h
  group RAK_SDK/rw_lib
    ../Hardware/RAK439_DriverLibs_V1.0.6/platform/: rw_lib_platform.c
    ../Hardware/RAK439_DriverLibs_V1.0.6/rw_lib/MDK_ARM/: rak_wifi_nos_ARM_CM4F.lib
  group RAK_SDK/example_nos
    ../Hardware/RAK439_DriverLibs_V1.0.6/examples_nos/: ap_sta.c apsta_test.c rw_app.h tcp_udp.c
  group RAK_SDK/platform/bsp
    ../Hardware/RAK439_DriverLibs_V1.0.6/platform/bsp/: bsp.c bsp.h
  group AD7606
    ../Hardware/AD7606/: ad7606.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
software components: CMSIS:CORE 4.1.0
